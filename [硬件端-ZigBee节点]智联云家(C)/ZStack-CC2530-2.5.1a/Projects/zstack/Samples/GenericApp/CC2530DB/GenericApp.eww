<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <batchBuild>
        <batchDefinition>
            <name>ALL</name>
            <member>
                <project>GenericApp</project>
                <configuration>CoordinatorEB</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>RouterEB</configuration>
            </member>
            <member>
                <project>GenericApp</project>
                <configuration>EndDeviceEB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
